Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2019-05-08T17:00:01
Made in: IfcPlusPlus

# IfcBuildingStorey (4)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 0
COBERTURA RAMPA | COBERTURA RAMPA | 230
PV. APOIO | PV. APOIO | 480
COBERTURA QUADRA | COBERTURA QUADRA | 530

# IfcPipeFitting: Adaptador para bocal semi-circular s/ terminação (9)
Type - PredefinedType: USERDEFINED
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm x 100 mm; Descrição: Adaptador para bocal semi-circular; Aplicação: Conexão; Classe: Calha metálica; Tipo: Adaptador para bocal semi-circular s/ terminação
Name | In
AP-1 | COBERTURA RAMPA
AP-1 | COBERTURA QUADRA
AP-2 | COBERTURA QUADRA
AP-3 | COBERTURA QUADRA
AP-4 | COBERTURA QUADRA
AP-5 | COBERTURA QUADRA
AP-6 | COBERTURA QUADRA
AP-7 | COBERTURA QUADRA
AP-8 | COBERTURA QUADRA

# IfcPipeFitting: Joelho 90- coluna (16)
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm; Descrição: Joelho 90- coluna; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 90- coluna
Name | In
AP-1 | TÉRREO
AP-13 | TÉRREO
AP-15 | TÉRREO
AP-16 | TÉRREO
AP-17 | TÉRREO
AP-6 | TÉRREO
AP-7 | TÉRREO
AP-8 | TÉRREO
AP-1 | PV. APOIO
AP-2 | PV. APOIO
AP-3 | PV. APOIO
AP-4 | PV. APOIO
AP-5 | PV. APOIO
AP-6 | PV. APOIO
AP-7 | PV. APOIO
AP-8 | PV. APOIO

# IfcPipeFitting: Joelho 90- desce (9)
Type - PredefinedType: BEND
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm; Descrição: Joelho 90- desce; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 90- desce
Name | In
AP-5 | TÉRREO
AP-10 | PV. APOIO
AP-11 | PV. APOIO
AP-12 | PV. APOIO
AP-13 | PV. APOIO
AP-15 | PV. APOIO
AP-16 | PV. APOIO
AP-17 | PV. APOIO
AP-9 | PV. APOIO

# IfcPipeFitting: Junção simples (2)
In: TÉRREO
Type - PredefinedType: JUNCTION
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm- 100 mm; Descrição: Junção simples; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção simples

# IfcPipeFitting: Luva simples- coluna (8)
In: COBERTURA RAMPA
Type - PredefinedType: CONNECTOR
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm; Descrição: Luva simples- coluna; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Luva simples- coluna
Name
AP-13
AP-15
AP-16
AP-17
AP-5
AP-6
AP-7
AP-8

# IfcPipeSegment: Calha retangular (12)
Type - PredefinedType: GUTTER
Pset_PipeSegmentTypeGutter - Slope: 1.000000
Pset_Identificação_Elemento - Rede: Pluvial; Classe: Calha metálica; Tipo: Calha retangular; Aplicação: Calha retangular
Name | In | Comprimento | Nome
 | COBERTURA RAMPA | 970 | 50 mm x 100 mm
 | COBERTURA RAMPA | 130.01 | 50 mm x 100 mm
 | COBERTURA QUADRA | 110.01 | 100 mm x 100 mm
2 x  | COBERTURA QUADRA | 560.03 | 100 mm x 100 mm
4 x  | COBERTURA QUADRA | 600.03 | 100 mm x 100 mm
 | COBERTURA QUADRA | 630.03 | 100 mm x 100 mm
 | COBERTURA QUADRA | 70 | 100 mm x 100 mm
 | COBERTURA QUADRA | 670.03 | 100 mm x 100 mm

# IfcPipeSegment: Tubo rígido c/ ponta lisa (46)
Type - PredefinedType: RIGIDSEGMENT
Pset_PipeSegmentTypeCommon - NominalDiameter: ø4"; InnerDiameter: 100
Pset_AltoQi_QiBuilder - Inclinação (%): 1.000000
Pset_Identificação_Elemento - Rede: Pluvial; Nome: 100 mm - 4"; Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Aplicação: Circular
Name | In | Comprimento
 | TÉRREO | 335.66
3 x  | TÉRREO | 330.56
2 x  | TÉRREO | 168.44
 | TÉRREO | 137.3
 | TÉRREO | 587.64
 | TÉRREO | 579.03
2 x  | TÉRREO | 154.33
 | TÉRREO | 553.02
 | TÉRREO | 1258.96
6 x  | COBERTURA RAMPA | 244.1
 | COBERTURA RAMPA | 250.1
 | COBERTURA RAMPA | 256.1
 | COBERTURA RAMPA | 242.8
8 x  | PV. APOIO | 83.1
8 x  | PV. APOIO | 238
 | COBERTURA QUADRA | 20.2
 | COBERTURA QUADRA | 31.8
 | COBERTURA QUADRA | 37.8
 | COBERTURA QUADRA | 25.8
 | COBERTURA QUADRA | 19.8
 | COBERTURA QUADRA | 25.4
 | COBERTURA QUADRA | 31.4
 | COBERTURA QUADRA | 37.4

# IfcWasteTerminal: Caixa de areia pluvial simples (2)
In: TÉRREO
Type - PredefinedType: GULLYSUMP
Pset_Identificação_Elemento - Rede: Pluvial; Nome: CA-60x60 cm; Descrição: Caixa de areia pluvial simples; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial simples
